require recipes-phosphor/images/obmc-phosphor-image.bb
